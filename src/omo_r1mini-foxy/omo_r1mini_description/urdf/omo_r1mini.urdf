Commit message: lidar setting fix

File: src/omo_r1mini-foxy/omo_r1mini_description/urdf/omo_r1mini.urdf (robot description, URDF)
Before this commit: robot omo_r1mini, 10 links, 9 joints
Joints:
- joint scan_joint: origin xyz=0 0 0.081 rpy=0 0 0 -> xyz=0 0 0.081 rpy=0 0 3.14
